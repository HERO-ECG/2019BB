# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\TimBase;..\..\User\led_test;..\..\User\SPI;..\..\User\MPU6500;..\..\User\CAN;..\..\User\delay;..\..\User\I2C_simu;..\..\User\MPU6050;..\..\User\MPU65xx;..\..\User\heat_ctrl;..\..\User\PID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_it.c main.c
    ../../User/usart/: usart.c
    ../../User/TimBase/: timbase.c
    ../../User/led_test/: led_test.c
    ../../User/CAN/: can.c
    ../../User/SPI/: spi.c
    ../../User/MPU6500/: MPU6500_spi.c
    ../../User/delay/: delay.c
    ../../User/I2C_simu/: I2C_simu.c
    ../../User/MPU6050/: MPU6050.c
    ../../User/MPU65xx/: MPU65xx.c
    ../../User/heat_ctrl/: heat_ctrl.c
    ../../User/PID/: PID.c
  group DOC
    ../../: 程序说明.txt
